FILESEXTRAPATHS_prepend := "${THISDIR}/linux-obmc:"
SRC_URI += "file://modules_on.cfg"
SRC_URI += "file://nfs.cfg"
